# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\HAL_Driver;..\Inc;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002bxx.s
    ../Src/: system_py32f002b.c
  group Application/User
    ../Src/: main.c py32f002b_hal_msp.c py32f002b_it.c rm1002_c_press_test.c usart.c usart.h adjust.c adjust.h led.c led.h tim.c tim.h arithmetic.c arithmetic.h flash.c flash.h iwdg.c iwdg.h app_flash.c
    ../Inc/: rm1002.h dev_config.h
  group BSP/py32f002bxx_Start_Kit
    ../Inc/: py32f002bxx_Start_Kit.c
  group Drivers/PY32F002B_HAL_Driver
    ../HAL_Driver/: py32f002b_hal.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_gpio.c py32f002b_hal_pwr.c py32f002b_hal_uart.c py32f002b_hal_cortex.c py32f002b_hal_adc.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_flash.c
software components: CMSIS:CORE 6.1.0
